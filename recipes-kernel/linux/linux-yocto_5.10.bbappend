KBRANCH_marvell-cn96xx  = "v5.10/standard/cn-sdkv4.18/cn96xx"

require linux-yocto-marvell-cn96xx.inc

LINUX_VERSION_marvell-cn96xx ?= "5.10.x"
