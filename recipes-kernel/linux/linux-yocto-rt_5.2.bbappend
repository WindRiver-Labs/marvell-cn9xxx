require linux-yocto-marvell-cn96xx.inc

KBRANCH_marvell-cn96xx  = "v5.2/standard/preempt-rt/cn96xx"

LINUX_VERSION_marvell-cn96xx ?= "5.2.x"
